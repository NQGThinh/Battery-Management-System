# Keil uVision project bms.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bms
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=3
  c include: .\Library\Inc;.\Library\Src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group BMS
    ./: main.c
  group Inc
    ./Library/Inc/: adc.h delay.h dma.h flash.h gpio.h kalman.h spi.h stm32f1xx.h
  group Src
    ./Library/Src/: adc.c delay.c dma.c flash.c gpio.c kalman.c spi.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
